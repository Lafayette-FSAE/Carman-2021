# Repository Lafayette-FSAE/Carman-2021

## KiCad design CarMan KiCAD Schematics/Logic_2022/PiShield.kicad_pcb

Board: 2 copper layers, 57.8 x 76.4 mm, 22 parts (21 on the bottom side), 15 nets.

Parts:
C1: 22uF; CAPC3216X180N
C2, C3: 100uF; CAPPRD350W60D800H1250
D1: D1; VAOL-S8GT4
D2: D2; VAOL-S8GT4
D3: D3; VAOL-S8GT4
J1: I2C Testing Header; PinHeader_1x04_P2.54mm_Vertical
J2: J2; Molex_MiniFit-JR-5556-04A_2x02x4.20mm_Straight
J3: J3; PinHeader_1x02_P2.54mm_Vertical
J4: J4; Molex_MiniFit-JR-5556-04A_2x02x4.20mm_Straight
J5: J5; PinHeader_2x05_P2.54mm_Vertical
J6: J6; PinHeader_1x02_P2.54mm_Vertical
J7: J7; PinHeader_1x02_P2.54mm_Vertical
L1: 22uH; VLS4012HBX220MN
PS1: PS1; P783Q24S5S
R1: 2K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2, R3: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R4: 120; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1: RaspberryPi3; Raspberry_Pi_3_B
U10: BNO_055
U11: Raspberry_Pi_RTC

Connections:
/3V3: R2.1, U1.1, U10.1, U11.2
/5V: C1.2, J1.1, PS1.9, PS1.10, PS1.11, R1.1, U1.2, U1.4
/24V: C2.1, J2.4, L1.1
/CAN_H: J4.1, J5.1, R4.1
/CAN_L: J4.2, J5.2, J7.1
/GLV_RTN: D1.1, D2.1, D3.1, J1.2, J2.3, J4.3, J5.3, U1.6, U1.9, U1.14, U1.20, U1.25, U1.30, U1.34, U1.39, U10.3, U10.6, U10.7, U11.5
/SCL_PI: J1.4, J2.1, U1.5, U10.4, U11.6
/SDA_PI: J1.3, J2.2, R3.1, U1.3, U10.5, U11.4
/SR_CTRL: J5.4, U1.31
unnamed: C1.1, C2.2, C3.2, PS1.5, PS1.6, PS1.7, PS1.8
unnamed: C3.1, L1.2, PS1.2, PS1.3, PS1.4
unnamed: D1.2, R1.2
unnamed: D2.2, R2.2
unnamed: D3.2, R3.2
unnamed: J7.2, R4.2

## KiCad design CarMan KiCAD Schematics/TSI/TSI_Rev.7/TSI_Rev.7.kicad_pcb

Parts:
J1: J1 TSV; Molex-0010844030
J2: J2 MC; Molex_MiniFit-JR-5556-08A_2x04x4.20mm_Straight
J3: J3 MC Direction Switch; Molex_MiniFit-JR-5556-04A_2x02x4.20mm_Straight
J4: J4 PC Relay; Molex_MiniFit-JR-5556-02A_2x01x4.20mm_Straight
J5: J5 DC Relay; Molex_MiniFit-JR-5556-02A_2x01x4.20mm_Straight
J6: J6 Current_Sensor; Current Sensor
J7: J7 IMD; Molex_MiniFit-JR-5556-08A_2x04x4.20mm_Straight
J8: J8 BP CAN & PWR; Molex_MiniFit-JR-5556-06A_2x03x4.20mm_Straight
J9: J9 COCKPIT; Molex_MiniFit-JR-5556-04A_2x02x4.20mm_Straight
J10: J10 COOL PWR; Molex_Mega-Fit_76829-0102_2x01_P5.70mm_Vertical
J11: J11 GLV PWR; Molex_MiniFit-JR-5556-04A_2x02x4.20mm_Straight
J12: J12 DASH/EPAL; Molex_MiniFit-JR-5556-08A_2x04x4.20mm_Straight
J13: J13 BP SL; Molex_MiniFit-JR-5556-04A_2x02x4.20mm_Straight
J14, J25: J14 RSP SL; Molex_MiniFit-JR-5556-04A_2x02x4.20mm_Straight
J15: J15 Testing Header; PinSocket_2x05_P2.54mm_Vertical
J16, J27: J16 ROLL TSAL; Molex_MiniFit-JR-5556-02A_2x01x4.20mm_Straight
J17, J23: J17 THROTTLE PLAUS.; Molex_MiniFit-JR-5556-06A_2x03x4.20mm_Straight
J18: J18 BRAKES; Molex_MiniFit-JR-5556-04A_2x02x4.20mm_Straight
J19: J19 RTDS & BRK LIGHT; Molex_MiniFit-JR-5556-04A_2x02x4.20mm_Straight
J20: J20 COOL SENSORS; Molex_MiniFit-JR-5556-06A_2x03x4.20mm_Straight
J21: J21 LSP; Molex_MiniFit-JR-5556-04A_2x02x4.20mm_Straight
J22, J24: J22 I2C; PinSocket_1x04_P2.54mm_Vertical
JP2: MC Directional Jumper; PinHeader_1x03_P2.54mm_Vertical
JP3: If CAN_Shield & Chassis_GND need to be shorted to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; PinHeader_1x02_P2.54mm_Vertical
JP10: Safety Loop Jumper: Battery Packs; PinHeader_1x02_P2.54mm_Vertical
JP11: Safety Loop Jumper: IMD; PinHeader_1x02_P2.54mm_Vertical
JP12: Safety Loop Jumper: BOT Switch; PinHeader_1x02_P2.54mm_Vertical
JP13: Safety Loop Jumper: RSP; PinHeader_1x02_P2.54mm_Vertical
JP14: Safety Loop Jumper: AIRS+, 24V; PinHeader_1x02_P2.54mm_Vertical
JP15: Safety Loop Jumper: J10 - Voltage; PinHeader_1x03_P2.54mm_Vertical
R11, R14: 2.2K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R118, R119: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R122: 120; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW2: IMD RST; SW_PUSH_6mm
SW3: AMS RST; SW_PUSH_6mm

Connections:
/3.3V: J22.3, J23.2; also elsewhere on the board
/5HV: J6.5, R118.2, R119.2; also elsewhere on the board
/5V: J20.2; also elsewhere on the board
/10V: J17.1; also elsewhere on the board
/12V_Cooling: J10.1; also elsewhere on the board
/24V: J7.2, J8.2, J11.1, J12.7, J13.4, JP10.1, JP11.1, JP14.2, JP15.2; also elsewhere on the board
/24V_AMS_RTN: J13.3, J21.3, JP10.2, SW3.1; also elsewhere on the board
/A1_HV: J6.2; also elsewhere on the board
/A2_HV: J6.3; also elsewhere on the board
/AIRS+: J13.2, J14.1, J18.3, JP13.1, JP14.1; also elsewhere on the board
/AIRS-: J7.1, J7.3, J7.4, J8.3, J9.3, J10.2, J11.2, J12.1, J13.1, J14.3, J16.2, J17.6, J19.2, J19.4, J20.3, J20.5, J22.4, J23.3, J24.3, R11.1, R14.1; also elsewhere on the board
/AMS_Button_RTN: J21.4, SW3.2; also elsewhere on the board
/AMS_FAULT_LED: J12.6; also elsewhere on the board
/APPS1: J17.2; also elsewhere on the board
/APPS1_RTN: J17.3, J17.4; also elsewhere on the board
/APPS2: J17.5; also elsewhere on the board
/BOT_Out: J18.2, JP12.2; also elsewhere on the board
/BP_CAN+: J8.5, J25.1, R122.2; also elsewhere on the board
/BP_CAN-: J8.4, J25.2, J27.2; also elsewhere on the board
/BRAKE_OUT: J18.4, J19.1; also elsewhere on the board
/CAN_Shield: J8.6, JP3.1
/COOL_24V: J11.4, JP15.3; also elsewhere on the board
/Chassis_GND: J8.1, JP3.2; also elsewhere on the board
/CoolTemp_In: J20.4; also elsewhere on the board
/DC_RELAY+: J5.1; also elsewhere on the board
/Drive_BTN: J9.1; also elsewhere on the board
/Drive_LED: J9.2; also elsewhere on the board
/FW: J2.7, J3.1, JP2.1, R118.1
/Flowrate: J20.1; also elsewhere on the board
/GEN_FAULT_EPAL: J12.3; also elsewhere on the board
/HV+: J1.2; also elsewhere on the board
/HV-: J1.3; also elsewhere on the board
/IGNI_VCC: J2.2; also elsewhere on the board
/IMD_Button_RTN: J21.2, SW2.2; also elsewhere on the board
/IMD_FAULT_LED: J12.5; also elsewhere on the board
/IMD_MHS: J7.5, R14.2
/IMD_Status: J7.8, J21.1, JP11.2, R11.2, SW2.1; also elsewhere on the board
/IO_Ground: J2.1, J2.3, J3.2, J5.2, J6.4, JP2.2; also elsewhere on the board
/MC+: J1.1; also elsewhere on the board
/MRESET_Contact: J14.2, JP13.2; also elsewhere on the board
/PC_RELAY+: J4.1; also elsewhere on the board
/PC_RELAY-: J4.2; also elsewhere on the board
/PGEC: J23.5; also elsewhere on the board
/PGED: J23.4; also elsewhere on the board
/PI_SHIELD_RTN: J25.3; also elsewhere on the board
/RTDS: J19.3; also elsewhere on the board
/RW: J2.6, J3.3, JP2.3, R119.1
/SCL: J22.2; also elsewhere on the board
/SDA: J22.1; also elsewhere on the board
/SL1_In: J11.3, JP15.1; also elsewhere on the board
/SL1_Out: J18.1, JP12.1; also elsewhere on the board
/SR_CTRL: J25.4; also elsewhere on the board
/Safety_Loop_EPAL: J12.2; also elsewhere on the board
/TSAL: J12.4, J16.1; also elsewhere on the board
/Test_Pin0: J15.1; also elsewhere on the board
/Test_Pin1: J15.2; also elsewhere on the board
/Test_Pin2: J15.3; also elsewhere on the board
/Test_Pin3: J15.4; also elsewhere on the board
/Test_Pin4: J15.5; also elsewhere on the board
/Test_Pin5: J15.6; also elsewhere on the board
/Test_Pin6: J15.7; also elsewhere on the board
/Test_Pin7: J15.8; also elsewhere on the board
/Test_Pin8: J15.9; also elsewhere on the board
/Test_Pin9: J15.10; also elsewhere on the board
/Throttle_HV: J2.5; also elsewhere on the board
/UART_RXD: J24.2; also elsewhere on the board
/UART_TXD: J24.1; also elsewhere on the board
/~MCLR: J23.1; also elsewhere on the board
unnamed: J27.1, R122.1

Notes on the sheet:
Battery Packs Safety Loop
TSV
Precharge Relay (NO)
Breakered 24V from GLV to TSI
IMD
HIGH VOLTAGE
RSP Safety Loop
Discharge Relay (NC)
Motor Controller
Cooling Subsystem Power
Cooling Sensors
COCKPIT
LSP IMD & AMS Reset Button
Dashboard/EPAL
Connected to Brake Pedals & BOT Switch
TSAL Roll Hoop Power
Throttle Plausiblity
RTDS & Brake Light
HIGH VOLTAGE
LOW VOLTAGE
Battery Pack CAN & Power
Current Sensor
High Voltage Connectors
(120 mA to open)
MC: FW = 13 RW = 14 (active low)
Jumpers and Shorts
LOW VOLTAGE
Safety Loop Testing Jumpers & Buttons
(2A > to open, 90mA nominal draw)
LOW VOLTAGE
Testing Header
Motor Controller Directional Switch
Easy access SDA & SCL pins
Pickit Programming Connector
UART
PI SHIELD Connector
CAN Terminator

Parts:
C1: 0.47u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2: 4.7u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C5, C37: 0.1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C12: 0.33u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C38: 15u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D6, D7, D15, D16, D17: GREEN LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder; Part Name VAOL-S8GT4
D8, D12, D13: 1N4001; D_DO-41_SOD81_P7.62mm_Horizontal
D14: SL_Status; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
IC1: TS431ILT; SOT95P280X145-5N
J29: PC Test Points; PinHeader_1x05_P2.54mm_Vertical
JP4: MC Power Testing Jumper; PinHeader_1x02_P2.54mm_Vertical
JP5: PC Relay Testing Jumper; PinHeader_1x02_P2.54mm_Vertical
K1: APAN3105; RELAY_APAN3105
PS1: THN_30-2415WI; CONV_PDQ10-Q24-D5-D
Q1: ZVP1320F; SOT23
Q3: SI1302DL-T1-E3; SOT-23
R4, R73: 5K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R46: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R47, R69: 499; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R56: 56K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R67, R102, R105, R108, R115, R116, R117: 2.4K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R72: 95K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R100, R101, R106: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R107: 1M; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
RV1: 3296W-1-103LF; Potentiometer_Bourns_3296W_Vertical
RV3: 10K; Potentiometer
TP7: Safety_Loop; TestPoint_Pad_D3.0mm
TP14: TSV_MIN_REF; TestPoint_Pad_D3.0mm
U9: STN3NF06L; SOT230P700X180-4N
U10: MC7805BDTRKG; DPAK229P990X238-4N
U12: REF3033; SOT-23; Mouser Part # REF3033AIDBZT
U19, U42: SN74HC00APWR; TSSOP-14_4.4x5mm_P0.65mm
U21, U35, U40: TLV2464CDR; SOIC127P600X175-14N
U27, U34, U37: TLP293; SOIC-4_4.55x2.6mm_P1.27mm

Connections:
/3.3V: U27.4; also elsewhere on the board
/5HV: C1.1, C5.2, C37.2, D8.1 (K), K1.C1, R46.1, R69.2, U10.3 (VO), U12.1 (IN), U19.14 (VCC), U37.4, U40.4 (V+), U42.14 (VCC); also elsewhere on the board
/5V: U35.4 (V+); also elsewhere on the board
/24V: C2.1, PS1.1 (+VIN(VCC)); also elsewhere on the board
/AIRS+: R108.1; also elsewhere on the board
/AIRS-: C2.2, D14.1 (K), PS1.2 (-VIN(GND)), R100.2, U34.2, U35.11 (V-), U37.2; also elsewhere on the board
/DC_RELAY+: D12.1 (K), Q1.3 (D); also elsewhere on the board
/IGNI_VCC: K1.NO; also elsewhere on the board
/IO_Ground: C1.2, C5.1, C12.2, C37.1, C38.2, D12.2 (A), D15.1 (K), D16.1 (K), D17.1 (K), IC1.5 (A), J29.1, JP4.1, JP5.1, PS1.5 (-VOUT), Q3.2 (S), R72.1, R73.1, R101.2, U9.3 (S), U10.2 (GND), U12.3 (GND), U19.7 (GND), U27.2, U34.3, U40.11 (V-), U42.7 (GND); also elsewhere on the board
/MC_Voltage: U21.12 (+); also elsewhere on the board
/PCDC_Circuit/3.3HV_REF: U12.2 (OUT), U40.13 (-)
/PCDC_Circuit/MC_95%: J29.3, R116.1, U19.2, U40.7
/PCDC_Circuit/PC_Control: J29.5, R4.2, R56.1, R102.2, U42.8, U42.12
/PCDC_Circuit/Safety_Loop_HV: J29.4, R73.2, R117.1, U19.10, U37.3, U42.13
/PCDC_Circuit/TSV_MIN_REF: IC1.3 (K), R46.2, RV3.2, TP14.1, U40.2 (-)
/PCDC_Circuit/TSV_Ready: J29.2, R115.1, U19.1, U40.1
/PC_RELAY+: C12.1, D13.1 (K), K1.M, PS1.3 (+VOUT), Q1.2 (S), R67.1, R107.1, U10.1 (VI); also elsewhere on the board
/PC_RELAY-: D6.1 (K), D13.2 (A), JP5.2, U9.2 (D), U9.4; also elsewhere on the board
/PC_Ready: R100.1, U27.3; also elsewhere on the board
/Safety_Loop: TP7.1, U35.3 (+); also elsewhere on the board
/TS_Voltage: U21.10 (+); also elsewhere on the board
unnamed: C38.1, R56.2, U40.12 (+)
unnamed: D6.2 (A), R67.2
unnamed: D7.1 (K), D8.2 (A), JP4.2, K1.C2, Q3.3 (D)
unnamed: D7.2 (A), R69.1
unnamed: D14.2 (A), R105.2
unnamed: D15.2 (A), R115.2
unnamed: D16.2 (A), R116.2
unnamed: D17.2 (A), R117.2
unnamed: IC1.4 (REF), R101.1, RV3.1
unnamed: Q1.1 (G), R106.2, R107.2
unnamed: Q3.1 (G), U40.14
unnamed: R4.1, U9.1 (G)
unnamed: R47.2, U37.1
unnamed: R72.2, RV1.1
unnamed: R102.1, U27.1
unnamed: R47.1, R105.1, U35.1, U35.2 (-)
unnamed: R106.1, U34.4
unnamed: R108.2, U34.1
unnamed: RV1.2, U40.5 (+)
unnamed: RV1.3, U21.8, U21.9 (-), U40.3 (+)
unnamed: U19.3, U19.4, U19.5
unnamed: U19.6, U19.9
unnamed: U19.8, U42.9
unnamed: U21.13 (-), U21.14, U40.6 (-)
unnamed: U42.10, U42.11

Notes on the sheet:
HIGH VOLTAGE SIGNALS
LOW VOLTAGE
24HV to 5HV Regulator
25mA
VOLTAGE REFERENCES & REGULATORS (HIGH VOLTAGE)
LOW VOLTAGE SIGNALS
24V (GLV) --> 24V (ISO)
PRECHARGE & DISCHARGE CIRCUIT
HIGH VOLTAGE
DC Relay (J5)
3.3HV Reference Voltage
Three Criteria for Pre Charge Relay to close:
Desired voltage from TSV_MIN_REF is approx. equal to 1.97HV - 2HV.
Pot can generate TSV_MIN_REF ranging from 1.24HV - 2.45HV.
TSV_MIN_REF Adjustable HV Reference
Let's say 45HV is the minimum TSV Voltage to operate circuit, 45HV * 1/61 voltage div. = 0.74HV 0.74HV + 1.24HV_Ref bias signal = 1.97HV 1.97HV -> TSV_MIN_REF
TSV_MIN_REF Derivation:
1. TS_Voltage & MC_Voltage w/in 95% of e/o 2. TS_Voltage > TSV_MIN_REF (approx. 1.97HV) 3. AIRS are closed (Safety_Loop_HV = 5HV)
SR-LATCH
3-Input AND Gate
95% of Voltage
Buffer
Flyback Diode
Voltage Comparator
PC Relay (J3)
Motor Controller Power Supply Relay
Pre-Charge Switch
TSV Minimum Voltage Check
NAND Package Power Supplies
MC Voltage 95% Check
PRE-CHARGE LOGIC CIRCUIT
Flyback diode
~Q'
SR Latching Logic
(Pre charge ready)
This state is not possible since whenver Safety_Loop_HV is low, the output of U19C must be high

Notices in the files:
parts and their libraries:
Copyright 2016 Accelerated Designs. All rights reserved.
