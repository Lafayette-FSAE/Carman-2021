# Repository Lafayette-FSAE/Carman-2021 (continued)

## KiCad design CarMan KiCAD Schematics/Logic/Logic.kicad_pcb (continued)

Parts:
C3: 0.1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C5: 1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C13: 0.01uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U4: PYB20-Q24-S5; CONV_PYB20-Q24-S5
U7: LT1763CS8-3.3PBF; LT1763CS8-3-PBF

Connections:
/3.3V_ISO: C13.1, U7.1 (OUT), U7.2 (SENSE); also elsewhere on the board
/5V_ISO: C5.1, U4.3 (+VO), U7.5 (~SHDN), U7.8 (IN); also elsewhere on the board
/24V: C3.1, U4.2 (VIN); also elsewhere on the board
/GLV_RTN: C3.2, U4.1 (GND); also elsewhere on the board
/ISO_RTN: C5.2, U4.5 (0V), U7.3 (GND_2), U7.6 (GND), U7.7 (GND_3); also elsewhere on the board
unnamed: C13.2, U7.4 (BYP)

Notes on the sheet:
SIGNALS
NON-ISO
ISO
24V -> 5V_ISO & 3.3V_ISO
5V_ISO -> 3.3V_ISO
24V_NON_ISO -> 5V_ISO

Board: 2 copper layers, 57.8 x 76.4 mm, 65 parts (29 on the bottom side), 45 nets.

## KiCad design CarMan KiCAD Schematics/GLV_BOBV6/GLV_BOBV6.kicad_pcb

Board: 2 copper layers, 79.5 x 60.3 mm, 23 parts (0 on the bottom side), 11 nets.

Parts:
C1, C3: 0.1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C2: 0.33uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
CR1: L78L05ACD13TR
D2 5V, D3 24V: LED; VAOL-S8GT4
H1, H2, H3, H4: MountingHole; MountingHole_2.5mm_Pad
J1 LSP: Conn_01x02; Molex_Mega-Fit_76829-0102_2x01_P5.70mm_Vertical
J2 Extra 24V, J3 CAN ISO: Conn_01x02; Molex_MiniFit-JR-5556-02A_2x01x4.20mm_Straight
J4 Logic, J5 TSI: Conn_02x02_Odd_Even; Molex_MiniFit-JR-5556-04A_2x02x4.20mm_Straight
J6 Breakers: J6; Molex_Mega-Fit_76829-0106_2x03_P5.70mm_Vertical
R1: 0.001; R_1210_3225Metric_Pad1.42x2.65mm_HandSolder
R2, R3, R8, R9: 10K; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U1: INA226AIDGSR
VAL: REF; lafLogo

Connections:
/5V_NON_ISO: C1.1, C3.2, CR1.1, R2.1, R3.1, R8.2, U1.6
/24V: C2.2, CR1.8, J2 Extra 24V.2, J3 CAN ISO.2, J4 Logic.4, J5 TSI.1, J6 Breakers.4, R9.2
/24V_NOT_BREAKERED: J6 Breakers.1, J6 Breakers.2, J6 Breakers.3, R1.1, U1.8, U1.9
/BATT+: J1 LSP.2, R1.2, U1.10
/BREAKER_OUT_COOL: J5 TSI.4, J6 Breakers.5
/BREAKER_OUT_SL: J5 TSI.3, J6 Breakers.6
/GLV_RTN: C1.2, C2.1, C3.1, CR1.2, CR1.3, CR1.6, CR1.7, D2 5V.1, D3 24V.1, J1 LSP.1, J2 Extra 24V.1, J3 CAN ISO.1, J4 Logic.3, J5 TSI.2, U1.1, U1.2, U1.7
/SCL_NOT_ISO: J4 Logic.1, R3.2, U1.5
/SDA_NOT_ISO: J4 Logic.2, R2.2, U1.4
unnamed: D2 5V.2, R8.1
unnamed: D3 24V.2, R9.1

## Commit log (part)

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2020-10-20 Testing
2020-10-20 Added Folders for each board
2020-10-20 Fixed .gitignore
2020-10-20 Zack test
2020-10-25 New Carman Library
2020-10-25 8 Pin Addition
2020-10-25 New Upload
2020-10-25 Top-Level TSI
2020-10-25 Updated Libraries and created logic board
2020-10-25 Added GLV Schematic
2020-10-25 TSI-TP
2020-10-26 Lib Update, TSi Update
2020-10-26 TSI-TP Update
2020-10-27 TSI update
2020-10-27 GLV Schematic Fix - Logic Power
2020-10-27 Finished Logic Board schematic and removed old schematics
2020-10-27 GLV Comment
2020-10-27 Added Datasheet Folder
2020-10-27 stupid
2020-10-27 Redo
2020-10-27 Update, error fix
2020-10-27 GLV Tentatively Finished
2020-10-27 GLV Tentatively Finished with part labels
2020-10-27 Sensors &Throttle ISO 2
2020-10-27 Finished temp/current sensor and TV ISO
2020-10-28 GLV with Cooling Connector
2020-10-28 Update lib, TSAL & CAN/GLV
2020-10-28 TSI Fixes - Hi Neal
2020-10-28 Updater
2020-10-28 oopdate
2020-10-28 Updated Logic to run off of 5V not 24V
2020-10-29 Fixed More TSI connections/renamed things
2020-10-29 TSI - Added 24V- 5v isolated converter, Scada relay, and fixed connections
2020-10-29 Res/Cap Value Updates & Organizational
2020-10-30 Added Cooling isolator and fault logic sheet
2020-10-30 Actually isolated things this time
2020-10-30 Pls help
2020-11-01 Segmented TSI connectors to be HV and LV, Removed redundant IMD LED logic.
2020-11-01 Updated GLV with breaker connectors and connections, changed I2C PU resistors, added remaining pwr flags.
2020-11-03 TSI J13 & TSI J14
2020-11-03 NO J12
2020-11-03 Removed CAN Transciever from CAN & GLV Power, edited net listing on PCDC Circuit regarding Safety_Loop Iso and extraneous connector
2020-11-03 BP_HV - > Brake_Pressed_HV net list changes
2020-11-10 TSI Re-labeling
2020-11-10 changed logic isolation
2020-11-11 GLV with updated connector names, removed isolated converter and I2C isolator
2020-11-14 TSI with Cooling + Scada Relay, new Cooling Connector
2020-11-16 updated Epal and Sloop
2020-11-16 Updated Pi GPIO and connector between Logic and TSI
2020-11-16 updated Sloop once more
2020-11-17 Footprint Work II
2020-11-17 TSI: Added 24 to 12V converter, V dividers for IMD_Status, Throttle_PL, corrected pins 1-5 TSI-Logic Logic:24 to 5V non iso conv, safety_loop isolated, fixed I2C
2020-11-17 fixed some bullshit
2020-11-17 Smoll
2020-11-18 Sloop Latching Logique
2020-11-18 Added BOT brake light breaking
2020-11-18 Aesthetics, IMD Relay
2020-11-19 TSI Foot printing
2020-11-19 Carman Footprint Library, GLV PCB v1
2020-11-20 Logic Footprints in General Library, Added Logic LEDs
2020-11-20 GLV PCB redone to be cleaner
2020-11-22 GLV PCB edge cuts, logos, increased BATT+ trace widths, Gerber files
2020-11-23 Logic PCB started, Pi 3B footprint fixed
2020-11-23 footprinting, datasheeting, general bug fixes * Added TSAL & TSAL Cockpit labels
2020-11-24 Logic PCB updates, Fixed I2C and ground connections in Logic
2020-11-24 - TSI editing, Xsistor selection, footprints
2020-11-26 updated Sloop once again
2020-11-26 Safety Loops Edits to TSI
2020-11-27 - Aesthetics - TSI Safety Loop Edits - Battery pack connection editing
2020-11-27 Too big Logic PCB finished
2021-01-11 GLV removed 24V to dash and 24V to BP headers. Logic almost done pending, design review
2021-01-12 Added footprints for MCP6004
2021-01-12 Added Footprints for TS 912
2021-01-12 TSI Footprints
2021-01-13 TSI Footprinting (~80%) - Added Molex - Added Current Sensor
2021-01-13 Bug Fixins
2021-01-13 TSI Footprinting (~95%) - Added Silk Screen Images from last years projects (not added to any libraries, just folder)
2021-01-13 TSI Footprinting (~98%) - Assigned U41 footprint to PS1 footprint. Not able to find PS1 footprint. Referenced last years design and took measurement on PCB. Measured as the same distances between poi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
2021-01-13 Small edits
2021-01-13 TSI Footprinting (100%) - Created symbol for connector J1
2021-01-14 - Updated logic header footprints on TSI
2021-01-14 Started TSI layout
2021-01-14 TSI High Voltage placed
2021-01-14 Organized LV into groupings
2021-01-14 Organization
2021-01-14 more TSI work
2021-01-15 Low Voltage (Throttle Plausibility)
2021-01-15 LV Edited
2021-01-16 TSI Layout (~65%)
2021-01-16 TSI (~95%) - Verify Safety Loop signal - Remove Testing connector/change signals - Place Test pads - Aesthetic tweaks
2021-01-16 TSI (~97%)
2021-01-17 TSI (~98.5%)
2021-01-18 TSI (~99%) - Confirmed TSI pin headers and logic pin header alignment - Divided board into several sections - Placed TSV testing pads and made last connection
2021-01-18 Updated component links
2021-01-18 Updated Components
2021-01-19 C13 Footprint
2021-01-19 TSI (99.5%) - Updated footprints on pcb
2021-01-19 TSI Signal Review ISSUES: - PCDC 'Pre_Charge_Ready' and 'PC_Ready' discrepancy - TSI Rev.4 IC1, IC4 -> PCDC & Isolators
    REMOVED SIGNALS:
    Throttle Plausibility
    - PC_Ready
    - Drive_BTN
    PCDC
    - HV+
2021-01-20 Updated trace width and connector naming
2021-01-20 TSI Updated
2021-01-26 TSI removed inverter and made SL and Fault signals Active High using opto isolator for sch and pcb
2021-02-01 GLV Design Review Fixes
2021-02-02 Logic Design Review Fixes
2021-02-02 Redrew TSI iso lines
2021-02-02 Changed TSI to ground pour
2021-02-03 Changed order of names on TSI Board
2021-02-03 Contemplated homicide and fixed PC schematic
2021-02-09 - Increased spacing between edge cuts and 24V - Labeled more in Low voltage
2021-02-09 Small Changes
2021-02-09 TSI Silkscreen Connector Descriptions added
2021-02-09 TSI silkscreen updated
2021-02-09 GLV DR Fixes
2021-02-09 Z-Man
2021-02-09 GLV and Logic ready to be ordered
2021-02-10 Zipped Gerber Files for all 3 boards
2021-02-16 Added 3D models for TSI board
2021-02-16 Added 3D models for GLV board (previous message was actually for Logic board)
2021-02-19 Editing TSI
2021-02-22 Logic with Mounting Holes and Silkscreen Descriptions, new Gerber files
2021-02-22 repushing credentials
2021-02-22 - Updating TSI
2021-02-22 Set IGNI_GND to IO_Ground, remove extraneous wire connection, Loaded new netlist
2021-02-22 More Updates
2021-02-24 - Stoof
2021-02-25 -> Updated battery pack connections, matched order with that on the pacman board
2021-02-26 Updated TSI notation
2021-02-27 - Changed signals - J16.3 24V-> AIRS+ - Removed 'GEN_Fault_LED' (tied to MRESET Contact), I think it was the old General fault led signal
2021-02-28 UPDATED AMS & IMD RELAY FOOTPRINT & SCHEMATIC
2021-02-28 Updated IMD Signals
2021-02-28 Small PCB Changes
2021-03-01 Edited Throttle Plausibility Braking circuit (was 24V, not AIRS+), renamed signals for clearer BRAKE_IN & BRAKE_OUT signals, BRAKE_OUT = Brake_Light
2021-03-01 Notes on relay
2021-03-01 -Updated RTDS, tested Xistor, can handle pulsed 90mA current
2021-03-02 Try poosh again
2021-03-02 Pin header updates
2021-03-02 Added LEDs for SCADA, AMS & IMD relays
2021-03-02 organizational update
2021-03-05 PCB Updates
2021-03-05 Small updates
2021-03-08 Updated Brake_Pressed_uC Signal
2021-03-09 TSI Updated & error fixes: added pull down resistors, and 5V_ISO_RTN
2021-03-12 ADDED K1-APAN3105 Relay to symbol and footprint libraries
2021-03-12 Updated C14 with mouser part number
2021-03-12 Updated D6 & D7 fields, assigned them specific LED that is also used by logic and GLV (VAOL-S8GT4)
2021-03-15 Throttle Plausibility comments
2021-03-15 Added comments
2021-03-16 Changed R1 from 76K to 1K, fixing the voltage reference (D2) issue for Throttle Plausibility
2021-03-17 - removed testing headers (All pins were easily testable, one that weren't received testing points) - Added pull up resistor at drain of SCADA Relay - Fixed issue with U27-PC_Ready signal not being i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
2021-03-17 Removed D11 (RTDS Zener diode), made RTDS sound warbled and trash
2021-03-17 Added datasheets
2021-03-26 Changed C60 from 1uF to 0.01uf
2021-03-29 - Added pull up resistor to U21B differential circuit - Removed zener across PC relay
2021-03-29 DC PC Relay Comments
2021-03-31 - Removing IC1/ Diffamp_Ref (1.24V)
2021-03-31 - Added a Throttle Plausible Green LED
2021-03-31 Small Changes & Updated PCB
2021-03-31 Added Pre-Charge Control Test Point
2021-04-01 - SR Control boosted and scada relay circuit edited
2021-04-02 Datasheets and notes
2021-04-02 Comments for PC/DC
2021-04-02 Added jumpers across HV-, HV+ & MC+ voltage dividers Comments added to PC Circuit
2021-04-05 Jumpers across AMS & IMD Reset button for testing capabilities Jumper across IMD for easier testing capability Remove Brake_Pressed_HV signal from TSI board, originally designed for regenerative brak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
2021-04-05 small push
2021-04-05 Added back 1.24HV_Ref signal. One reference signal purely supplies 1.24HV pull up for Sensors_Throttle_Voltage sheet. The other reference, which is adjustable by potentiometer RV3, drives the TSV_MIN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
2021-04-05 Resizing
2021-04-05 Updated U19 footprint, changed to TSSOP-14, cross-referenced footprint with mouser product info footprint
2021-04-06 - Removed capacitors across R16, R53, R6 - Capacitive load was too much for 1.24HV Ref - Notes on Pre-charge circuit & Throttle Plausibility - Cooling, Relays & Voltage Refs
2021-04-06 General signal directions -> i/o
2021-04-07 - Added Test point TSV_MIN_REF - Removed DC_RELAY- signal. changed DC_RELAY- to be IO_Ground instead of IO_Ground shorted to DC_RELAY-, question of net-listing names on board layout more than anythin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
2021-04-07 Changed D6, Pre-Charge LED to a better circuit, wasn't working before. floating voltage at gate of Xsistor U9 was turning it on always
2021-04-07 changed the "speical" footprint of U9 to the correct one
2021-04-07 Pre-Charge Works
2021-04-07 Updated TSI
2021-04-08 Logic schematic organized
2021-04-08 Updated Logic again
2021-04-08 small update
2021-04-08 smaller update
2021-04-08 Super organized logic
2021-04-09 organized
2021-04-09 Logic Update
2021-04-09 - Adding J10 -> non isolated i2C testing header
2021-04-09 Logic updated
2021-04-09 MEGA UPDATE - Changed PC_Ready isolation from logic ISO rtn to GLV_RTN (U27) because it is sent over GPIO - Changed GPIO pins - Added 24V -> 5V TLP stepdown for AMS_FAULT_LED & IMD_FAULT_LED (U29,U31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
2021-04-09 - Added SDA & SCL pull-up resistors (to 5V) - Confirmed that all inputs to the GPIO is 5V - Eliminated redundancy of SDA & SCL signals, one signal pervades through whole TSI board and is shorted to S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
2021-04-12 Redid PCB added new cooling converter footprint and symbol
2021-04-13 routed TSI board
2021-04-14 TSI Rev. 5.1 PCB Updates
2021-04-15 More TSI routing optimization
2021-04-15 Aggregated Logic to one connector
2021-04-16 logic & TSI lay out
2021-04-19 TSI Logic Changes
2021-04-23 Updated TSI Schematic
2021-04-23 Added Footprint for Pi RTC. organized board
2021-04-23 Small poosh
2021-04-24 Updated board & schematics
2021-04-26 Added one more safety loop jumper for easier testing of pre-charge/discharge circuit
2021-04-26 Logic, TSI & GLV revisions
2021-04-26 Finish cap connections - res values for CoolTemp_in ->TSI
2021-04-27 Logic Board layout done
2021-04-27 Logic board aesthetics
2021-04-27 updated GLV bypass cap current sensor
2021-04-28 KiCAD Library Reorganization - Easier for next year
2021-05-11 Edited
2021-05-12 TSi - Fixed Symbol issue for U5, I2C Isolator
2021-05-14 LOGIC: Added pull-up resistors on non-isolated side of I2C TSI: Added silkscreen labeling and comments GLV: Organized GLV schematic, increased mounting hole size to 3.5mm from 2.5mm
2022-02-08 Updated the wiring on the schematic according to the errata update from Marwa
2022-02-15 Updated the logic board schematic and layout
2022-03-07 Created the Pi Shield schematic and a new library for pican2
2022-03-07 Added the library from mouser as suggest in the new hardware update
2022-03-08 Added the Pi shield components as well as the footprints needed
2022-03-08 Created the PCB layout of the Pi shield
2022-03-09 Fixed the PCB layout wiring error detected by the rule checker
2022-03-09 TSI Rev.7 Sch
2022-03-10 TSI Should be final schematic
2022-03-10 removed u41 power
2022-03-10 PCB_Progress
2022-03-11 TSI Post-Nadovich
2022-03-11 TSI Post-Nadovich2
2022-03-11 TSI REV7 Final Schematic before Layout
2022-03-11 Fixed annotation issue
2022-03-11 Updated Schematic and removed extra footprints from PCB. Ready to begin routing new elements in.
2022-03-11 Finished PCB for REV7
