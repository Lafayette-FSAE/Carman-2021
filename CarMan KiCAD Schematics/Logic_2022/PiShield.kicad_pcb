# Repository Lafayette-FSAE/Carman-2021 (continued)

## KiCad design CarMan KiCAD Schematics/TSI/TSI_Rev.7/TSI_Rev.7.kicad_pcb (continued)

Parts:
C6, C52, C53: 0.1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C14: 1u; C_Rect_L18.0mm_W9.0mm_P15.00mm_FKS3_FKP3; Mouser Part# B32522C3105J189
C17: 4.7u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: GREEN LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder; Part Name VAOL-S8GT4
R3: 2.4K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R12: 120; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R15: 300; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R68: 100K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R74: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R97, R99: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R113, R114: 4.7K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW4: RTDS Test; SW_PUSH_6mm
TP12: TSAL_LV; TestPoint_Pad_D3.0mm
U1: RDE03110S12
U11, U13: TLP293; SOIC-4_4.55x2.6mm_P1.27mm
U43: NCD9830DBR2G; SOP65P640X120-16N
U46: SI8600AB-B-IS; SOIC127P600X175-8N

Connections:
/3.3V: C53.2, R3.1, R68.2, U46.8 (BVDD); also elsewhere on the board
/5V: C52.2, R113.2, R114.1, U43.10 (REF_IN/REF_OUT), U43.12 (A0), U43.13 (A1), U43.16 (VDD), U46.1 (AVDD); also elsewhere on the board
/24V: SW4.2, U11.4, U13.4; also elsewhere on the board
/AIRS-: C6.2, C17.2, C52.1, C53.1, D1.1 (K), R74.2, R99.2, U1.12 (-Vout), U11.2, U13.2, U43.9 (GND), U43.11 (COM), U46.4 (AGND), U46.5 (BGND); also elsewhere on the board
/APPS: U43.1 (CH0); also elsewhere on the board
/CoolTemp: U43.2 (CH1); also elsewhere on the board
/D_LED_CTRL: R15.2; also elsewhere on the board
/Drive_BTN: R97.1; also elsewhere on the board
/Drive_BTN_LOGIC: C6.1, R68.1, R97.2; also elsewhere on the board
/Drive_LED: R99.1, U11.3; also elsewhere on the board
/HV+: C14.1, U1.1 (+Vin); also elsewhere on the board
/HV-: C14.2, U1.23 (-Vin), U1.24 (-Vin); also elsewhere on the board
/RTDS: R74.1, SW4.1, U13.3; also elsewhere on the board
/RTDS_CTRL: R12.2; also elsewhere on the board
/SCL: U46.6 (BSCL); also elsewhere on the board
/SCL_5V: R114.2, U43.14 (SCL), U46.3 (ASCL); also elsewhere on the board
/SDA: U46.7 (BSDA); also elsewhere on the board
/SDA_5V: R113.1, U43.15 (SDA), U46.2 (ASDA); also elsewhere on the board
/TSAL: C17.1, TP12.1, U1.13 (+Vout); also elsewhere on the board
unnamed: D1.2 (A), R3.2
unnamed: R12.1, U13.1
unnamed: R15.1, U11.1

Notes on the sheet:
HIGH VOLTAGE
STATUS LIGHTS, TSAL, RTDS & ADC
LOW VOLTAGE SIGNALS
STA20502 RTDS BUZZER (.6A MAX) 3/1/21 - Pulsed at max of 90mA 3/1/21 - Tested RTDS, w/Xsistor, worked
COCKPIT (J9)
RTDS Control
TSAL
LOW VOLTAGE
RTDS (J18)
HIGH VOLTAGE SIGNALS
DRIVE BUTTON
RTDS Button for testing
I2C Isolator
Isolator is required because the Ref_In must be equal to the max value of the analog inputs and cannot be greater than by VDD. At the same time, however, SDA and SCL are considered high if they are > 0.7*VDD. Since SDA and SCL are 3.3V, they would never be considered high.

Parts:
C3, C7, C8, C10, C11, C15, C16, C22, C26, C27, C39: 0.1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D2: TL431PS; MSOP-8_3x3mm_P0.65mm
D4: RED LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D11: GREEN LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J28: Pedal_Out TP; PinSocket_1x02_P2.54mm_Vertical
Q2: MMBF170; SOT-23
R1: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R5, R8, R17, R18, R19, R20, R22, R23, R24, R26, R36, R37, R40, R42, R44, R49, R98: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R21, R27: 100K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R28, R29: 4K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R32, R35: 499; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R34: 9.31K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R38, R103: 2.4K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R39: 2K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R43: 3K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
RV2: 1K; Potentiometer
SW1: TS5A3159DBVT; SOT95P280X145-6N
TP1: APPS1_ISO; TestPoint_Pad_D3.0mm
TP2: APPS_DIFF; TestPoint_Pad_D3.0mm
TP3: APPS1_b; TestPoint_Pad_D3.0mm
TP9: APPS2_b; TestPoint_Pad_D3.0mm
TP17: TP; TestPoint_Pad_D3.0mm
U3, U6: TS912; SOIC127P600X175-8N
U7, U18: TLV2464CDR; SOIC127P600X175-14N
U8: 74ACT11030; SOIC127P600X175-14N
U16: TS372CDT; SOIC127P600X175-8N
U30: TLP293; SOIC-4_4.55x2.6mm_P1.27mm
U47: MCP23008-xSS; SSOP-20_5.3x7.2mm_P0.65mm

Connections:
/3.3V: U30.4; also elsewhere on the board
/5V: C16.1, C26.1, C39.1, R8.2, R32.1, R36.1, R37.1, SW1.5 (V+), U7.4 (V+), U8.1, U8.2, U8.11, U18.4 (V+), U47.6 (~RESET), U47.20 (VDD); also elsewhere on the board
/10V: C3.1, C11.1, C22.1, R28.1, U3.8 (V+), U6.8 (V+), U16.8 (VCC+); also elsewhere on the board
/24V: R1.2; also elsewhere on the board
/AIRS+: C27.1; also elsewhere on the board
/AIRS-: C3.2, C8.2, C10.2, C11.2, C15.2, C16.2, C22.2, C26.2, C27.2, C39.2, D2.6 (A), D4.1 (K), D11.1 (K), J28.3, Q2.2 (S), R18.2, R19.2, R24.1, R29.2, R35.2, R43.2, R44.2, R98.2, SW1.2 (GND), U3.4 (V-), U6.4 (V-), U7.11 (V-), U8.4, U16.4 (VCC-), U18.11 (V-), U30.2, U47.3 (A2), U47.4 (A1), U47.5 (A0), U47.9 (VSS); also elsewhere on the board
/APPS: R39.2, R43.1; also elsewhere on the board
/APPS1: R21.2; also elsewhere on the board
/APPS1_RTN: C10.1, D2.1 (K), R1.1, R17.1; also elsewhere on the board
/APPS2: R27.2; also elsewhere on the board
/BRAKE_OUT: R49.2; also elsewhere on the board
/Brake_Pressed_uC: R98.1, U30.3; also elsewhere on the board
/Pedal_Out: J28.2, SW1.1 (NO), U18.1, U18.2 (-), U18.10 (+)
/SCL_5V: U47.1 (SCL); also elsewhere on the board
/SDA_5V: U47.2 (SDA); also elsewhere on the board
/TSAL: J28.1; also elsewhere on the board
/Throttle_EN: R44.1, SW1.6 (IN); also elsewhere on the board
/Throttle_LV: SW1.4 (COM); also elsewhere on the board
/Throttle_PL: R42.1, TP17.1, U8.5, U18.5 (+); also elsewhere on the board
/Throttle_Plausibility/0.24V_REF: R34.2, R35.1, U7.6 (-), U7.13 (-), U18.9 (-)
/Throttle_Plausibility/4.76V_REF: R32.2, R34.1, U7.3 (+), U7.10 (+)
/Throttle_Plausibility/APPS1_ISO: C7.1, R20.1, TP1.1, U3.1, U7.2 (-), U7.5 (+)
/Throttle_Plausibility/APPS1_ISO_NG: U7.7, U8.12, U47.17 (GP5)
/Throttle_Plausibility/APPS1_ISO_NS: U7.1, U8.9, U47.16 (GP4)
/Throttle_Plausibility/APPS1_b: R5.2, R22.2, TP3.1, U6.1, U6.2 (-)
/Throttle_Plausibility/APPS2_ISO_NG: U7.14, U8.14, U47.19 (GP7)
/Throttle_Plausibility/APPS2_ISO_NS: U7.8, U8.13, U47.18 (GP6)
/Throttle_Plausibility/APPS2_b: R23.2, R39.1, R40.1, TP9.1, U6.6 (-), U6.7, U7.9 (-), U7.12 (+)
/Throttle_Plausibility/APPS_DIFF: R26.1, TP2.1, U3.7, U16.2 (NEG1), U16.5 (POS2)
/Throttle_Plausibility/APPS_WIN1: R37.2, U8.3, U16.1 (OUT1), U47.14 (GP2)
/Throttle_Plausibility/APPS_WIN2: R36.2, U8.8, U16.7 (OUT2), U47.15 (GP3)
unnamed: C7.2, R8.1, R20.2, U3.2 (-)
unnamed: C8.1, R21.1, U6.3 (+)
unnamed: C15.1, R27.1, U6.5 (+)
unnamed: D2.8 (REF), R17.2, R18.1
unnamed: D4.2 (A), R38.1
unnamed: D11.2 (A), R103.1
unnamed: Q2.1 (G), R42.2
unnamed: Q2.3 (D), R40.2, U18.3 (+)
unnamed: R5.1, R19.1, U3.3 (+)
unnamed: R22.1, R24.2, U3.5 (+)
unnamed: R23.1, R26.2, U3.6 (-)
unnamed: R28.2, RV2.1, U16.3 (POS1)
unnamed: R29.1, RV2.2, RV2.3, U16.6 (NEG2)
unnamed: R38.2, U18.6 (-), U18.7
unnamed: R49.1, U30.1
unnamed: R103.2, U18.8

Notes on the sheet:
LOW VOLTAGE SIGNALS
*Subtracts 5V from APPS1 to bring signal into 0-5V range*
APPS 5V Offset Bias
Decoupling Cap for U18
*Need 1% tolerance for R17 & R18*
Decoupling Cap
Plausibility Window (0.5V)
Open/Short Window (90% Travel)
Decoupling Cap for U6
APPS1_b & APPS2_b
THROTTLE PLAUSIBILITY STATUS LIGHTS
APPS1 STEPDOWN
THROTTLE PLAUSIBILITY
PIC THROTTLE ENABLE SWITCH
Bypass Cap
Brake Light (J18)
Brake Pressed Switch (J17)
Throttle Plausibility Connects to pedals: APPS2 2K POT
A switch that is controlled by Throttle_EN. Pin 1 shorted to pin 4 when pin 6 HIGH
Voltage Comparator
Throttle Plausibility Connects to pedals: APPS1 2K POT
TP (J16)
5.55V
4.44V
*The outputs of the voltage comparator are both high if the differential between APPS1_b and APPS2_b is between the 4.44V-5.55V window*
*5-10V Range*
*0-5V Range*
*If the APPS1_ISO and APPS2_b fall outside the range of 0.24V-4.76V a short/open is assumed*
(Plausible)
(Implausible)
Decoupling Cap for U7
If RED LED is on, GREEN LED is off --> APPS shorted to GLV_RTN If RED LED is off, GREEN LED is on --> Throttle is plausible If RED LED is on, GREEN LED is on --> APPS shorted to 5V supply If RED LED is off, GREEN LED is off --> Board is off OR major malfunction
*Output is logic low if all values are high and 5V if any values are low*
Convert to 0-3.3V RATIO 3/5
Through ADC to PIC
Open/Short Window Ref Voltage Generators
I2C Address 0x20 (0100000 - 0100[A2 A1 A0])

Parts:
C13: 100uF; CP_Radial_D8.0mm_P3.50mm; PART ELXY350ETC101MH12D
C18, C28, C34, C36: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C19, C33: 0.1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C29: 0.01u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C31: 1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D3: MMSZ5231B-7-F; D_SOD-123
D5, D9, D10: GREEN LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder; Part Name VAOL-S8GT4
JP9: If CAN_Shield & Chassis_GND need to be shorted to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; PinHeader_1x02_P2.54mm_Vertical
K2: G5LE-1-E; G5LE-1-E DC24
K3, K4: SFS2-DC24V
PS2: KUB4812QB-10A; 24V-12V-NON-ISO-COOLING-CONVERTER
R25, R33, R45, R55: 2.4K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R52: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R54: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R61: 1.5K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R65: 2K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R80: 1.6K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R81, R82, R83: 1.2K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R92: 120; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R124: 1.8K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R125: 3.3K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
TP10: 5V_TP; TestPoint_Pad_D3.0mm
TP11: 3.3V_TP; TestPoint_Pad_D3.0mm
TP13: 10V_TP; TestPoint_Pad_D3.0mm
TP15: SL1_IMD_Out; TestPoint_Pad_D3.0mm
TP16: SL1_Out; TestPoint_Pad_D3.0mm
U2: Bottom Right; MountingHole_3.5mm_Pad
U14: Bottom Left; MountingHole_3.5mm_Pad
U15: Top Left; MountingHole_3.5mm_Pad
U17: Top Right; MountingHole_3.5mm_Pad
U20, U24, U28, U32: TLP293; SOIC-4_4.55x2.6mm_P1.27mm
U36: LT1763CS8-3.3PBF; SOIC127P600X175-8N
U38: PDQ10-Q24-D5-D; CONV_PDQ10-Q24-D5-D

Connections:
/3.3V: C28.1, C29.1, R65.1, TP11.1, U36.1 (OUT), U36.2 (SENSE); also elsewhere on the board
/5V: C31.1, C33.1, JP9.1, TP10.1, U24.4, U36.5 (‎SHDN), U36.8 (IN), U38.4 (Comm); also elsewhere on the board
/10V: TP13.1, U38.3 (+Vout); also elsewhere on the board
/12V_Cooling: C18.1, PS2.7 (SENSE+), PS2.8 (+VO); also elsewhere on the board
/24V: C34.1, C36.1, D3.1 (K), K2.2, K3.5, K4.5, R52.1, R61.1, U28.4, U38.1 (+Vin); also elsewhere on the board
/24V_AMS_RTN: K4.8; also elsewhere on the board
/AIRS+: R33.2, R45.2; also elsewhere on the board
/AIRS-: C13.2, C18.2, C19.2, C28.2, C31.2, C33.2, C34.2, C36.2, D5.1 (K), D9.1 (K), D10.1 (K), K3.2, K4.2, PS2.3 (-VIN), PS2.4 (-VO), R54.2, R55.2, R125.2, U20.2, U20.3, U24.2, U28.2, U32.3, U36.3 (GND_2), U36.6 (GND), U36.7 (GND_3), U38.2 (-Vin), U38.5 (-Vout); also elsewhere on the board
/AMS_Button_RTN: K4.1, K4.7, R82.2; also elsewhere on the board
/AMS_FAULT_LED: K4.6; also elsewhere on the board
/BOT_Out: K2.1; also elsewhere on the board
/COOL_24V: C13.1, PS2.1 (+VIN); also elsewhere on the board
/Chassis_GND: U17.1; also elsewhere on the board
/CoolTemp: C19.1, R65.2, R80.1; also elsewhere on the board
/CoolTemp_In: R80.2; also elsewhere on the board
/Cooling_CTRL: JP9.2, PS2.2 (CTRL); also elsewhere on the board
/Flowrate: R124.1; also elsewhere on the board
/Flowrate_LOGIC: R124.2, R125.1; also elsewhere on the board
/GEN_FAULT_EPAL: R61.2, U20.4; also elsewhere on the board
/IMD_Button_RTN: K3.1, K3.7, R81.2; also elsewhere on the board
/IMD_FAULT_LED: K3.6; also elsewhere on the board
/IMD_Status: K3.8; also elsewhere on the board
/MRESET_Contact: K2.4, R25.2, R83.2; also elsewhere on the board
/PI_SHIELD_RTN: U32.2; also elsewhere on the board
/Relays_Cooling_Voltage_Refs/SL1_IMD_Out: K3.10, K4.9, TP15.1
/Relays_Cooling_Voltage_Refs/SR_CTRL_Boosted: D3.2 (A), K2.5, R52.2, U32.4
/SL1_In: K3.9; also elsewhere on the board
/SL1_Out: K4.10, TP16.1; also elsewhere on the board
/SR_CTRL: R92.2; also elsewhere on the board
/Safety_Loop: R55.1, U24.3; also elsewhere on the board
/Safety_Loop_EPAL: R54.1, U28.3; also elsewhere on the board
unnamed: C29.2, U36.4 (BYP)
unnamed: D5.2 (A), R82.1
unnamed: D9.2 (A), R81.1
unnamed: D10.2 (A), R83.1
unnamed: R25.1, U20.1
unnamed: R33.1, U28.1
unnamed: R45.1, U24.1
unnamed: R92.1, U32.1

Notes on the sheet:
3.3V REGULATOR
Cooling, Relays and Voltage Refs
LOW VOLTAGE SIGNALS
DC/DC Converter 9V-36V to 5V/-5V
DC/DC Converter
SCADA Relay
COOLING CONTROL & SENSORS
Zacky Bear Doesn't Like
IMD Relay
AMS Relay
AMS Reset BTN
DC/DC Converter 24V to 12V 10A
Control Signal used as a psuedo relay
SFS2-DC24 has built in diode across terminals
SCADA Relay
EPAL & SAFETY LOOP LED SIGNALS
IMD Reset BTN
25mA passed to EPAL when MRESET_CONTACT is low
NC relay, if SR_CTRL_Boosted is high the Safety Loop opens
Cooling R1
Lights up when coils are not conducting (BOT & SCADA OK)
(Coil rated for 16.7 mA)
Needs to be rated for 1/2W
15 mA through coil
Cooling Sensors (J19)
Dashboard (J12)
LSP (J20)
Jumper to force voltage to be sent to cooling if Cooling_CTRl isn't working
Lights up when coils are conducting
BOT (J17)
5V-3.3V Voltage Divider

Parts:
C20, C21, C32, C35, C50, C51: 0.1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C30, C40, C41: 100p; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
IC2: TS431ILT; SOT95P280X145-5N
JP6, JP7, JP8: Testing Jumper; PinHeader_1x02_P2.54mm_Vertical
R6, R16, R53, R59, R62, R63, R89, R90, R91, R93, R94, R95, R96, R104: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R7, R9, R10, R13, R76, R77, R78, R84, R85, R86, R87, R88: 150K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R50, R51: 4.7K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R58: 15K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R64, R66: 24.9K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R70: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
TP8: Throttle_HV; TestPoint_Pad_D3.0mm
U4: ACPL-C870; SOIC127P1150X330-8N
U5: SI8600AB-B-IS; SOIC127P600X175-8N
U21, U26, U40: TLV2464CDR; SOIC127P600X175-14N
U25: NCD9830DBR2G; SOP65P640X120-16N

Connections:
/3.3V: C51.2, U5.8 (BVDD); also elsewhere on the board
/5HV: C20.1, C21.1, C35.1, C50.2, R50.2, R51.2, R70.1, U4.8 (VDD2), U5.1 (AVDD), U21.4 (V+), U25.10 (REF_IN/REF_OUT), U25.13 (A1), U25.16 (VDD), U26.4 (V+); also elsewhere on the board
/5V: C32.1, U4.1 (VDD1); also elsewhere on the board
/A1_HV: U25.5 (CH4); also elsewhere on the board
/A2_HV: U25.4 (CH3); also elsewhere on the board
/AIRS-: C30.2, C32.2, C51.1, R59.2, U4.3 (SHDN), U4.4 (GND1), U5.5 (BGND); also elsewhere on the board
/HV+: JP7.2, R86.1; also elsewhere on the board
/HV-: JP8.2, R88.1; also elsewhere on the board
/IO_Ground: C20.2, C21.2, C35.2, C41.1, C50.1, IC2.5 (A), R64.1, U4.5 (GND2), U5.4 (AGND), U21.11 (V-), U25.9 (GND), U25.11 (COM), U25.12 (A0), U26.11 (V-); also elsewhere on the board
/MC+: JP6.2, R13.1; also elsewhere on the board
/MC_Voltage: R89.2, U21.7, U25.8 (CH7); also elsewhere on the board
/SCL: U5.6 (BSCL); also elsewhere on the board
/SDA: U5.7 (BSDA); also elsewhere on the board
/Sensors_Throttle_Voltage/1.24HV_REF: IC2.3 (K), IC2.4 (REF), R6.1, R16.1, R53.1, R70.2, R91.1, R104.1
/Sensors_Throttle_Voltage/SCL_HV: R51.1, U5.3 (ASCL), U25.14 (SCL)
/Sensors_Throttle_Voltage/SDA_HV: R50.1, U5.2 (ASDA), U25.15 (SDA)
/TS_Voltage: R90.2, U21.1, U25.7 (CH6); also elsewhere on the board
/Throttle_HV: C40.1, R66.1, TP8.1, U40.8; also elsewhere on the board
/Throttle_LV: R58.2; also elsewhere on the board
unnamed: C30.1, R58.1, R59.1, U4.2 (VIN)
unnamed: C40.2, R63.1, R66.2, U40.9 (-)
unnamed: C41.2, R62.1, R64.2, U40.10 (+)
unnamed: JP6.1, R6.2, R7.2, U26.12 (+)
unnamed: JP7.1, R53.2, R78.2, U26.5 (+)
unnamed: JP8.1, R16.2, R76.2, U26.10 (+)
unnamed: R7.1, R9.2
unnamed: R10.1, R13.2
unnamed: R9.1, R10.2
unnamed: R62.2, U4.7 (VOUT+)
unnamed: R63.2, U4.6 (VOUT-)
unnamed: R76.1, R77.2
unnamed: R77.1, R87.2
unnamed: R78.1, R84.2
unnamed: R84.1, R85.2
unnamed: R85.1, R86.2
unnamed: R87.1, R88.2
unnamed: R89.1, R96.2, U21.6 (-)
unnamed: R90.1, R94.2, U21.2 (-)
unnamed: R91.2, R93.2, U21.3 (+)
unnamed: R93.1, U26.6 (-), U26.7
unnamed: R94.1, R96.1, U26.8, U26.9 (-)
unnamed: R95.1, U26.13 (-), U26.14
unnamed: R95.2, R104.2, U21.5 (+)

Notes on the sheet:
Bypass Cap for U21
Bypass Cap for U26
Divider circuit is jumped when executing TSI HV Test Plan. Cuts the need for a 100HV+ input to an approx. 1-2HV input
Voltage Divider Ratio: 1/61
Difference between HV+ & HV-
Buffer
Difference between MC+ & HV-
LOW VOLTAGE
HIGH VOLTAGE
LOW VOLTAGE SIGNALS
HIGH VOLTAGE SIGNALS
THROTTLE VOLTAGE ISOLATOR
1.24HV Diff-Amp Reference
VOLTAGE REFERNCE
I2C Address: 0x4A (1001010-10010[A1,A0])
I2C Isolator
Hooks up to PIC32
From simulation- Lowpass cutoff: 268kHz
