# Repository Lafayette-FSAE/Carman-2021 (continued)

## KiCad design CarMan KiCAD Schematics/TSI/TSI_Rev.7/TSI_Rev.7.kicad_pcb (continued)

Parts:
C43, C44, C45, C46, C47, C48, C49: 0.1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
L1: 28nH; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R111, R112: 4.7K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R120: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R121, R123: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R126: 1.8K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R127: 3.3K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U44: PIC32MZ2048EFM064-I_PT; QFP50P1200X1200X120-64N
U45: MCP2551-I_SN; SOIC127P600X175-8N; Manufacturer_Part_Number MCP2551-I/SN; Mouser Part Number 579-MCP2551-I/SN

Connections:
/3.3V: C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, L1.1, L1.2, R111.1, R112.1, R120.2, U44.8 (VDD), U44.19 (AVDD), U44.26 (VDD), U44.39 (VDD), U44.54 (VDD), U44.60 (VDD); also elsewhere on the board
/5V: U45.3 (VDD); also elsewhere on the board
/AIRS-: C43.1, C44.1, C45.1, C46.1, C47.1, C49.2, R123.2, R127.2, U44.7 (VSS), U44.25 (VSS), U44.34 (VUSB3V3), U44.40 (VSS), U44.55 (VSS), U44.59 (VSS), U45.2 (VSS); also elsewhere on the board
/BP_CAN+: U45.7 (CANH); also elsewhere on the board
/BP_CAN-: U45.6 (CANL); also elsewhere on the board
/Brake_Pressed_uC: U44.31 (OSC1/CLKI/RC12); also elsewhere on the board
/Cooling_CTRL: U44.46 (AERXD1/ETXD3/RPD0/RTCC/INT0/RD0); also elsewhere on the board
/D_LED_CTRL: U44.49 (EMDIO/AEMDIO/RPD1/SCK1/RD1); also elsewhere on the board
/Drive_BTN_LOGIC: U44.48 (SOSCO/RPC14/T1CK/RC14); also elsewhere on the board
/Flowrate_LOGIC: U44.18 (PGED2/AN47/RPB7/RB7); also elsewhere on the board
/PC_Ready: U44.32 (OSC2/CLKO/RC15); also elsewhere on the board
/PGEC: U44.15 (PGEC1/VREF-/CVREF-/AN1/RPB1/RB1); also elsewhere on the board
/PGED: U44.16 (PGED1/VREF+/CVREF+/AN0/RPB0/PMA6/RB0); also elsewhere on the board
/PIC32/CAN_RXD: U44.42 (RPF5/SCL5/PMA8/RF5), U45.4 (RXD)
/PIC32/CAN_TXD: U44.41 (RPF4/SDA5/PMA9/RF4), U45.1 (TXD)
/PIC32/Throttle_PL_LOGIC: R126.2, R127.1, U44.2 (AN16/ETXD0/PMD6/RE6)
/RTDS_CTRL: U44.58 (TRD0/SQID0/ERXD1/PMD0/RE0); also elsewhere on the board
/SCL: R111.2, U44.6 (AN12/C2IND/RPG8/SCL4/PMA3/RG8); also elsewhere on the board
/SDA: R112.2, U44.5 (AN13/C1INC/RPG7/SDA4/PMA4/RG7); also elsewhere on the board
/Safety_Loop: U44.47 (SOSCI/RPC13/RC13); also elsewhere on the board
/Test_Pin0: U44.3 (AN15/ETXD1/PMD7/RE7); also elsewhere on the board
/Test_Pin1: U44.4 (AN14/C1IND/RPG6/SCK2/PMA5/RG6); also elsewhere on the board
/Test_Pin2: U44.10 (AN11/C2INC/RPG9/PMA2/RG9); also elsewhere on the board
/Test_Pin3: U44.11 (AN45/C1INA/RPB5/RB5); also elsewhere on the board
/Test_Pin4: U44.30 (AN10/EMDC/AEMDC/RPB15/OCFB/PMA0/RB15); also elsewhere on the board
/Test_Pin5: U44.29 (AN9/RPB14/SCK3/PMA1/RB14); also elsewhere on the board
/Test_Pin6: U44.12 (AN4/C1INB/RB4); also elsewhere on the board
/Test_Pin7: U44.13 (AN3/C2INA/RPB3/RB3); also elsewhere on the board
/Test_Pin8: U44.14 (AN2/C2INB/RPB2/RB2); also elsewhere on the board
/Test_Pin9: U44.38 (RPF3/USBID/RF3); also elsewhere on the board
/Throttle_EN: U44.51 (AERXERR/ETXCLK/RPD3/SCL3/RD3); also elsewhere on the board
/Throttle_PL: R126.1; also elsewhere on the board
/UART_RXD: U44.44 (ECOL/RPD10/SCL1/SCK4/RD10); also elsewhere on the board
/UART_TXD: U44.45 (AERXCLK/AEREFCLK/ECRS/RPD11/PMCS1/PMA14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); also elsewhere on the board
/~MCLR: R121.2, U44.9 (~MCLR~); also elsewhere on the board
unnamed: C48.1, U44.20 (AVSS), U44.35 (VSS)
unnamed: C49.1, R120.1, R121.1
unnamed: R123.1, U45.8 (RS)

Notes on the sheet:
NS=Not Shorted NG=Not Grounded
5V-3.3V Voltage Divider

Board: 2 copper layers, 203.2 x 165.1 mm, 295 parts (0 on the bottom side), 192 nets.

Other parts of the board:
C25: 0.1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
VAL: REF; lafLogo

Their connections:
/5V: C25.1; also elsewhere on the board
/AIRS-: C25.2; also elsewhere on the board

File CarMan KiCAD Schematics/TSI/TSI_Rev.7/TSI_Rev.7_BOM.csv (part):

"Source:","C:\Users\Eli\Documents\21Semester1\ECE 491\GitHub_Repositories\Carman-2021\CarMan KiCAD Schematics\TSI\TSI_Rev.7\TSI_Rev.7.sch"
"Date:","3/10/2022 5:36:43 PM"
"Tool:","Eeschema (5.1.9)-1"
"Generator:","C:\Program Files\KiCad\bin\scripting\plugins/bom_csv_grouped_by_value.py"
"Component Count:","283"

"Individual Components:"

"Item","Qty","Reference(s)","Value","LibPart","Footprint","Datasheet","Arrow Part Number","Arrow Price/Stock","Description","Details","Digikey","Field4","Field5","Field6","Field7","Field8","Height","MANUFACTURER","MPN","Man.","Manufacturer_Name","Manufacturer_Part_Number","Mouser Link","Mouser Part #","Mouser Part Number","Mouser Part#","Mouser Price/Stock","Note","OC_FARNELL","OC_NEWARK","PACKAGE","PART","Part Name","STANDARD","SUPPLIER","URL"
"","","C1","0.47u","TSI_Rev.5-rescue:CAP-pspice","Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","~","","","","","","","","","","","","","","","","","","","","","","","","","","","","","",""
"","","C2","4.7u","TSI_Rev.5-rescue:CAP-pspice","Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","~","","","","","","","","","","","","","","","","","","","","","","","","","","","","","",""
"","","C3","0.1u","TSI_Rev.5-rescue:CAP-pspice","Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","~","","","","","","","","","","","","","","","","","","","","","","","","","","","","","",""
"","","C5","0.1u","TSI_Rev.5-rescue:CAP-pspice","Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","~","","","","","","","","","","","","","","","","","","","","","","","","","","","","","",""
"","","C6","0.1u","TSI_Rev.5-rescue:CAP-pspice","Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","~","","","","","","","","","","","","","","","","","","","","","","","","","","","","","",""
"","","C7","0.1u","TSI_Rev.5-rescue:CAP-pspice","Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","~","","","","","","","","","","","","","","","","","","","","","","","","","","","","","",""
"","","C8","0.1u","TSI_Rev.5-rescue:CAP-pspice","Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","~","","","","","","","","","","","","","","","","","","","","","","","","","","","","","",""
"","","C10","0.1u","TSI_Rev.5-rescue:CAP-pspice","Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","~","","","","","","","","","","","","","","","","","","","","","","","","","","","","","",""
"","","C11","0.1u","TSI_Rev.5-rescue:CAP-pspice","Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","~","","","","","","","","","","","","","","","","","","","","","","","","","","","","","",""
"","","C12","0.33u","TSI_Rev.5-rescue:CAP-pspice","Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","~","","","","","","","","","","","","","","","","","","","","","","","","","","","","","",""
"","","C13","100uF","TSI_Rev.5-rescue:CAP-pspice","Capacitor_THT:CP_Radial_D8.0mm_P3.50mm","https://www.mouser.com/ProductDetail/United-Chemi-Con/ELXY35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","","","","","","","","","","","","","","","","","","","","","","","","","","ELXY350ETC101MH12D","","","",""
"","","C14","1u","TSI_Rev.5-rescue:CAP-pspice","Capacitor_THT:C_Rect_L18.0mm_W9.0mm_P15.00mm_FKS3_FKP3","https://www.tdk-electronics.tdk.com/inf/20/20/db/fc_2009/B32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","","","","","","","","","","","","","","","","","","","","B32522C3105J189","","","","","","","","","",""
"","","C15","0.1u","TSI_Rev.5-rescue:CAP-pspice","Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","~","","","","","","","","","","","","","","","","","","","","","","","","","","","","","",""
"","","C16","0.1u","TSI_Rev.5-rescue:CAP-pspice","Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","~","","","","","","","","","","","","","","","","","","","","","","","","","","","","","",""
"","","C17","4.7u","TSI_Rev.5-rescue:CAP-pspice","Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","~","","","","","","","","","","","","","","","","","","","","","","","","","","","","","",""
"","","C18","10u","TSI_Rev.5-rescue:C-Device","Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","~","","","","","","","","","","","","","","","","","","","","","","","","","","","","","",""
"","","C19","0.1u","TSI_Rev.5-rescue:CAP-pspice","Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","~","","","","","","","","","","","","","","","","","","","","","","","","","","","","","",""
"","","C20","0.1u","TSI_Rev.5-rescue:CAP-pspice","Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","~","","","","","","","","","","","","","","","","","","","","","","","","","","","","","",""
"","","C21","0.1u","TSI_Rev.5-rescue:CAP-pspice","Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","~","","","","","","","","","","","","","","","","","","","","","","","","","","","","","",""
"","","C22","0.1u","TSI_Rev.5-rescue:CAP-pspice","Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","~","","","","","","","","","","","","","","","","","","","","","","","","","","","","","",""
"","","C25","0.1u","TSI_Rev.5-rescue:CAP-pspice","Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","~","","","","","","","","","","","","","","","","","","","","","","","","","","","","","",""
"","","C26","0.1u","TSI_Rev.5-rescue:CAP-pspice","Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","~","","","","","","","","","","","","","","","","","","","","","","","","","","","","","",""
"","","C27","0.1u","TSI_Rev.5-rescue:CAP-pspice","Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","~","","","","","","","","","","","","","","","","","","","","","","","","","","","","","",""
"","","C28","10u","TSI_Rev.5-rescue:CAP-pspice","Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","~","","","","","","","","","","","","","","","","","","","","","","","","","","","","","",""
"","","C29","0.01u","TSI_Rev.5-rescue:CAP-pspice","Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","~","","","","","","","","","","","","","","","","","","","","","","","","","","","","","",""
"","","C30","100p","TSI_Rev.5-rescue:CAP-pspice","Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","~","","","","","","","","","","","","","","","","","","","","","","","","","","","","","",""
"","","C31","1u","TSI_Rev.5-rescue:CAP-pspice","Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","~","","","","","","","","","","","","","","","","","","","","","","","","","","","","","",""
"","","C32","0.1u","TSI_Rev.5-rescue:CAP-pspice","Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","~","","","","","","","","","","","","","","","","","","","","","","","","","","","","","",""
"","","C33","0.1u","TSI_Rev.5-rescue:CAP-pspice","Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","~","","","","","","","","","","","","","","","","","","","","","","","","","","","","","",""
"","","C34","10u","TSI_Rev.5-rescue:CAP-pspice","Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","~","","","","","","","","","","","","","","","","","","","","","","","","","","","","","",""
"","","C35","0.1u","TSI_Rev.5-rescue:CAP-pspice","Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","~","","","","","","","","","","","","","","","","","","","","","","","","","","","","","",""
"","","C36","10u","TSI_Rev.5-rescue:CAP-pspice","Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","~","","","","","","","","","","","","","","","","","","","","","","","","","","","","","",""
"","","C37","0.1u","TSI_Rev.5-rescue:CAP-pspice","Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","~","","","","","","","","","","","","","","","","","","","","","","","","","","","","","",""
"","","C38","15u","TSI_Rev.5-rescue:CAP-pspice","Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder","~","","","","","","","","","","","","","","","","","","","","","","","","","","","","","",""
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
## KiCad design CarMan KiCAD Schematics/Logic/Logic.kicad_pcb

Parts:
C2, C10, C11, C12, C18, C19, C21: 0.1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C4, C6, C7, C8, C9: 0.1u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C20: 0.33uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
CR1: L78L05ACD13TR
D1: 5V ISO; VAOL-S8GT4
D2: 3.3V ISO; VAOL-S8GT4
D3: SDA ISO; VAOL-S8GT4
D4: STATE_OUT_1; VAOL-S8GT4
D5: STATE_OUT_2; VAOL-S8GT4
D6: STATE_OUT_3; VAOL-S8GT4
D7: 24V; VAOL-S8GT4
D8: 5V NI; VAOL-S8GT4
J1: J1 MC Can Line; Molex_MiniFit-JR-5556-04A_2x02x4.20mm_Straight
J2: J2 NI I2C; PinSocket_1x04_P2.54mm_Vertical
J3: J3 Logic-TSI; PinSocket_2x05_P2.54mm_Vertical
J4: J4 GLV BOB; Molex_MiniFit-JR-5556-04A_2x02x4.20mm_Straight
J5: J5 PICKit 3; PinSocket_1x06_P2.54mm_Vertical
J6: J6 NI CAN; PinSocket_1x02_P2.54mm_Vertical
L1: 28nH; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R1, R2, R3, R8, R9, R11, R12, R13, R14, R15: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R4: 1k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R5, R6: 1K; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R7: 120; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R16: 2K; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U1: MCP9700AT-HTT-Sensor_Temperature-Logic-rescue; SOT-23
U3: PIC32MZ2048EFM064-I_PT; QFP50P1200X1200X120-64N
U5: ISO1050DUB; SOP-8_6.62x9.15mm_P2.54mm
U6: RaspberryPi3; Raspberry_Pi_3_B
U9: ISO1541DR
U10: BNO_055
U11: Raspberry_Pi_RTC

Connections:
/3.3V_ISO: C4.2, C6.2, C7.2, C8.2, C9.2, C10.1, C18.1, J3.7, J5.2, L1.1, L1.2, R1.2, R2.2, R3.2, R5.1, U3.8 (VDD), U3.19 (AVDD), U3.26 (VDD), U3.39 (VDD), U3.54 (VDD), U3.60 (VDD), U9.1 (VCC1), U10.1 (Vin), U11.2 (Vin); also elsewhere on the board
/5V_ISO: C11.1, R16.1, U1.1 (Vdd), U5.1 (VCC1), U6.2 (5V), U6.4 (5V); also elsewhere on the board
/5V_NON_ISO: C12.2, C19.2, C21.2, CR1.1 (VOUT), J2.1, R12.1, R14.1, R15.1, U5.8 (VCC2), U9.8 (VCC2); also elsewhere on the board
/24V: C20.1, CR1.8 (VIN), J4.4, R13.1; also elsewhere on the board
/BP_CAN+: J1.1, J3.8, R7.2, U5.7 (CANH); also elsewhere on the board
/BP_CAN-: J1.2, J3.6, J6.2, U5.6 (CANL); also elsewhere on the board
/Cooling_CTRL: J3.1, U3.3 (AN15/ETXD1/PMD7/RE7)
/FlowRate: J3.9, U3.18 (PGED2/AN47/RPB7/RB7)
/GLV_RTN: C12.1, C19.1, C20.2, C21.1, CR1.2 (GND), CR1.3 (GND), CR1.6 (GND), CR1.7 (GND), D7.1 (K), D8.1 (K), J2.2, J4.3, U5.5 (GND2), U9.5 (GND2); also elsewhere on the board
/GPIO25: U6.22 (GPIO_25); also elsewhere on the board
/ISO_RTN: C2.1, C4.1, C6.1, C7.1, C8.1, C9.1, C10.2, C11.2, C18.2, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), J1.3, J3.5, J5.3, U1.3 (GND), U3.7 (VSS), U3.20 (AVSS), U3.25 (VSS), U3.34 (VUSB3V3), U3.35 (VSS), U3.40 (VSS), U3.55 (VSS), U3.59 (VSS), U5.4 (GND1), U6.6 (GND), U6.9 (GND), U6.14 (GND), U6.20 (GND), U6.25 (GND), U6.30 (GND), U6.34 (GND), U6.39 (GND), U9.4 (GND1), U10.3 (GND), U10.6 (PS1), U10.7 (PS0), U11.5 (GND); also elsewhere on the board
/PGEC: J5.5, U3.15 (PGEC1/VREF-/CVREF-/AN1/RPB1/RB1)
/PGED: J5.4, U3.16 (PGED1/VREF+/CVREF+/AN0/RPB0/PMA6/RB0)
/PIC_RXD: U3.42 (RPF5/SCL5/PMA8/RF5), U5.2 (RXD)
/PIC_TXD: U3.41 (RPF4/SDA5/PMA9/RF4), U5.3 (TXD)
/PI_SPI_CEO: U6.24 (GPIO_8); also elsewhere on the board
/PI_SPI_MISO: U6.21 (MISO); also elsewhere on the board
/PI_SPI_MOSI: U6.19 (MOSI); also elsewhere on the board
/PI_SPI_SCLK: U6.23 (SCLK); also elsewhere on the board
/SCL_ISO_PI: R1.1, U3.6 (AN12/C2IND/RPG8/SCL4/PMA3/RG8), U6.5 (SCL), U9.3 (SCL1), U10.4 (SCL), U11.6 (SCL)
/SCL_TSI_GLV: J2.4, J3.4, J4.1, R14.2, U9.6 (SCL2)
/SDA_ISO_PI: R2.1, R6.1, U3.5 (AN13/C1INC/RPG7/SDA4/PMA4/RG7), U6.3 (SDA), U9.2 (SDA1), U10.5 (SDA), U11.4 (SDA)
/SDA_TSI_GLV: J2.3, J3.2, J4.2, R12.2, U9.7 (SDA2)
/SR_CTRL: J3.3, U6.31 (GPIO_6)
/STATE_OUT_1: R8.1, U3.46 (AERXD1/ETXD3/RPD0/RTCC/INT0/RD0)
/STATE_OUT_2: R9.1, U3.49 (EMDIO/AEMDIO/RPD1/SCK1/RD1)
/STATE_OUT_3: R11.1, U3.50 (ETXERR/AETXEN/RPD2/SDA3/RD2)
/V_OUT_TEMP: U1.2 (Vout), U3.29 (AN9/RPB14/SCK3/PMA1/RB14)
/~MCLR~: J5.1, R4.1, U3.9 (~MCLR~)
unnamed: C2.2, R3.1, R4.2
unnamed: D1.2 (A), R16.2
unnamed: D2.2 (A), R5.2
unnamed: D3.2 (A), R6.2
unnamed: D4.2 (A), R8.2
unnamed: D5.2 (A), R9.2
unnamed: D6.2 (A), R11.2
unnamed: D7.2 (A), R13.2
unnamed: D8.2 (A), R15.2
unnamed: J6.1, R7.1

Notes on the sheet:
Non-Isolated Voltage LEDs
Isolated Status LEDs
Logic-TSI Connector
24->5V (NON-ISO) Voltage Regulator
Bi-Directional I2C Isolator
5V & 3.3V have same isolated return
Motor Controller Can Line
LOGIC HEADERS
GLV 24V and I2C to logic
PICKit Programming Header
TOP LEVEL
Isolated Can Transceiver
Analog Temperature Sensor
NON-ISO I2C Testing Header
Drive State LEDs
Mounted External Components
Symbol & Footprint for IMU to be mounted to the Logic board
Symbol & Footprint for Pi RTC to be mounted to the Logic board
NON-ISO CAN Testing Header
HIERARCHICAL SHEETS

Parts:
C1, C14, C15: 0.1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C16, C17: 22pF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R10: 4k7; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U2: ISO1050DUB; SOP-8_6.62x9.15mm_P2.54mm
U8: MCP2515-xSO; SOIC-18W_7.5x11.6mm_P1.27mm
Y1: 16MHz; XTAL_ECS-160-20-5PX-TR

Connections:
/5V_ISO: C14.2, C15.1, R10.1, U2.1 (VCC1), U8.18 (VDD); also elsewhere on the board
/5V_NON_ISO: C1.2, U2.8 (VCC2); also elsewhere on the board
/BP_CAN+: U2.7 (CANH); also elsewhere on the board
/BP_CAN-: U2.6 (CANL); also elsewhere on the board
/GLV_RTN: C1.1, U2.5 (GND2); also elsewhere on the board
/GPIO25: U8.12 (~INT); also elsewhere on the board
/ISO_RTN: C14.1, C15.2, C16.1, C17.1, U2.4 (GND1), U8.9 (VSS); also elsewhere on the board
/PI_SPI_CEO: U8.16 (~CS); also elsewhere on the board
/PI_SPI_MISO: U8.15 (SO); also elsewhere on the board
/PI_SPI_MOSI: U8.14 (SI); also elsewhere on the board
/PI_SPI_SCLK: U8.13 (SCK); also elsewhere on the board
unnamed: C16.2, U8.7 (OSC2), Y1.1
unnamed: C17.2, U8.8 (OSC1), Y1.2
unnamed: R10.2, U8.17 (~RESET)
unnamed: U2.2 (RXD), U8.2 (RXCAN)
unnamed: U2.3 (TXD), U8.1 (TXCAN)

Notes on the sheet:
SIGNALS
NON-ISO
ISO
PiHat & CAN Transceiver
Isolated Can Transceiver
CAN Controller with SPI Interface
